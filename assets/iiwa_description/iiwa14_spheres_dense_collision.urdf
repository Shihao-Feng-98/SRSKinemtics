Commit message: feat: vis

File: assets/iiwa_description/iiwa14_spheres_dense_collision.urdf (robot description, URDF)
Before this commit: robot iiwa14, 11 links, 10 joints
Links:
- removed link iiwa_link_ee
Joints:
- removed joint tool0_joint
